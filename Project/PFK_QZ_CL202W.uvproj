# Keil uVision project PFK_QZ_CL202W.uvproj, settings and files
target PFK_QZ_CL202W (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: PFK_QZ_CL202W +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Bsp;..\User
  group PFK_QZ_CL202W
    ../User/: main.c MyConfig.h
    ../Bsp/: io.c io.h relay.c relay.h rs485.c rs485.h delay.c delay.h watchdog.c watchdog.h
    ../doc/: readme.txt
